# IAR project vcan_Kinetis.ewp, settings and files
configuration FN15_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FN1M0xxx15 Freescale MK60FN1M0xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60F15; MK60FN15
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vcan_Kinetis.hex
  ILINK.IlinkOutputFile: vcan_Kinetis.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N1M.icf
  ILINK.IlinkAdditionalLibs: ..\..\Lib\CMSIS\iar_cortexM4l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FN15_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60F15; MK60FN15
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: vcan_Kinetis.srec
configuration FX15_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60F15; MK60FX15
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60X512.icf
configuration FX15_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60F15; MK60FX15
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
configuration DZ10_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB; ..\..\Board\Accessories; ..\..\Board\Accessories\MPU6050; ..\..\Board\Accessories\IMU; ..\..\Board\Accessories\Driver
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
configuration DZ10_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
  group App
    ../../App/: main.c MK60_conf.c MK60_it.c
    ../../App/Inc/: MK60_conf.h MK60_it.h PORT_cfg.h
  group Board
    ../../Board/Accessories/: flashload.c
    ../../Board/src/: LDC1314.c VCAN_ASCII.c VCAN_computer.c VCAN_key.c VCAN_key_event.c VCAN_LED.C VCAN_NRF24L0.c VCAN_NRF24L0_MSG.c VCAN_OLED.c VCAN_RTC_count.C
    ../../Board/Accessories/Driver/: VCAN_IO_I2C.c
    ../../Board/Accessories/MPU6050/: VCAN_MPU6050.c
    ../../Board/Accessories/IMU/: VCAN_MPU6050_IMU.c
  group Chip
    ../../Chip/inc/: common.h
    ../../Chip/src/: misc.c MK60_adc.c MK60_can.c MK60_dac.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_flexbus.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_usb.c MK60_wdog.c SOFTWARE_I2C.c vectors.c
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
  group LIB/FatFs
    ../../Lib/FatFs/: diskio.c ff.c
  group LIB/USB
    ../../Lib/USB/: USB.c USB_CDC.c
